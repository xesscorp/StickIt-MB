# Repository xesscorp/StickIt-MB

File README.md:

StickIt! Main Motherboard
=================================================================

The StickIt! main motherboard is used with the 
[XuLA & XuLA2 FPGA boards](http://www.xess.com/store/fpga-boards/) to interface
with PMODs and/or the Raspberry Pi.

The documentation, schematic and PCB files for this motherboard are included in the subdirectories.
Design files for other StickIt! peripheral modules that plug into this motherboard can
be found in other repositories, such as [this one](https://github.com/xesscorp/StickIt).

Everybody likes pictures, so here are some pictures of the StickIt! Board:

## KiCad design pcb/StickIt-RPi.kicad_pcb

Parts:
C1, C3: 22uF; c_elec_5x5.3
C2, C4: 4.7uF; R_0805_HandSoldering
C5: 0.1uF; R_0805_HandSoldering
CON1: BARREL_JACK
GPIO1: RPi_GPIO; Pin_Header_Straight_2x20
GR1, GR2, GR3: Grove; GROVE_MALE
J1: XuLA_IO_HDR; XuLA_IO_Hdr
J3, J4, J5: JSHORTNORMAL; xess-JSHORT
JP1, JP2, JP3: JUMPER3; HDR_1x3
JP4, JP5, JP6, JP7, JP8, JP9, JP10: JUMPER; HDR_1x2
PM1, PM2, PM3: PMOD_SCKT-12
R1: 1K; R_0805_HandSoldering
RN1: 3.9K; CTS_742C043
SW1: SW_PUSH; RS-282G05A3-SM_RT
TP1: JUMPER; HDR_1x2
U1: NCV1117; SOT-223
U2: CAT24C32; SOIC-8-N

Connections:
+3.3V: C3.1, C4.1, C5.1, J3.2, J4.2, J5.2, JP1.3, JP2.3, JP3.3, JP7.1, R1.1, RN1.1, RN1.2 (1), U1.2 (OUT), U1.4 (HS), U2.8 (VCC)
+3.3V-RPi: GPIO1.1 (3.3V), GPIO1.17 (3.3V), JP7.2
+5V: C1.1, C2.1, JP1.1, JP2.1, JP3.1, JP4.2, JP5.2, JP6.2, U1.3 (IN)
+5V-RPi: GPIO1.2 (5V), GPIO1.4 (5V), JP4.1
+5V-XuLA: J1.3 (+5V), JP5.1
CHAN0: GPIO1.37 (BCM26), J1.22 (Chan0), JP10.1, PM1.1 (AIO1)
CHAN1: GPIO1.38 (BCM20_MOSI), GR1.2 (IO2), J1.23 (Chan1), PM1.8 (BIO2)
CHAN2: GPIO1.35 (BCM19_MISO), J1.24 (Chan2), PM1.2 (AIO2)
CHAN3: GPIO1.36 (BCM16), J1.25 (Chan3), PM1.9 (BIO3)
CHAN4: GPIO1.33 (BCM13), J1.26 (Chan4), PM1.3 (AIO3)
CHAN5: GPIO1.31 (BCM6), J1.27 (Chan5), PM1.10 (BIO4)
CHAN6: GPIO1.32 (BCM12), J1.28 (Chan6), PM1.4 (AIO4)
CHAN7: GPIO1.26 (BCM7_CE1), J1.29 (Chan7)
CHAN8: GPIO1.24 (BCM8_CE0), J1.30 (Chan8)
CHAN9: GPIO1.22 (BCM25), J1.31 (Chan9)
CHAN10: GPIO1.18 (BCM24), J1.32 (Chan10)
CHAN11: GPIO1.16 (BCM23), J1.33 (Chan11)
CHAN12: GPIO1.12 (BCM18_PCM_C), J1.34 (Chan12)
CHAN13: GPIO1.10 (BCM15_RXD), J1.35 (Chan13)
CHAN14: GPIO1.8 (BCM14_TXD), J1.36 (Chan14)
CHAN15: J1.20 (Chan15), PM2.1 (AIO1)
CHAN16: GR2.1 (IO1), J1.19 (Chan16), PM2.7 (BIO1)
CHAN17: J1.18 (Chan17), PM2.2 (AIO2)
CHAN18: GR2.2 (IO2), J1.17 (Chan18), PM2.8 (BIO2)
CHAN19: J1.16 (Chan19), PM2.3 (AIO3)
CHAN20: J1.15 (Chan20), PM2.9 (BIO3)
CHAN21: J1.14 (Chan21), PM2.4 (AIO4)
CHAN22: GPIO1.29 (BCM5), J1.13 (Chan22), PM2.10 (BIO4)
CHAN23: GPIO1.23 (BCM11_SCLK), J1.12 (Chan23), PM3.1 (AIO1)
CHAN24: GPIO1.21 (BCM9_MISO), GR3.1 (IO1), J1.11 (Chan24), PM3.7 (BIO1)
CHAN25: GPIO1.19 (BCM10_MOSI), J1.10 (Chan25), PM3.2 (AIO2)
CHAN26: GPIO1.15 (BCM22), GR3.2 (IO2), J1.9 (Chan26), PM3.8 (BIO2)
CHAN27: GPIO1.13 (BCM27_PCM_D), J1.8 (Chan27), PM3.3 (AIO3)
CHAN28: GPIO1.11 (BCM17), J1.7 (Chan28), PM3.9 (BIO3)
CHAN29: GPIO1.7 (BCM4_GPCLK0), J1.6 (Chan29), PM3.4 (AIO4)
CHAN30: GPIO1.5 (BCM3_SCL), J1.5 (Chan30), PM3.10 (BIO4)
CHAN31: GPIO1.3 (BCM2_SDA), J1.4 (Chan31)
CHANCLK: GPIO1.40 (BCM21_SCLK), GR1.1 (IO1), J1.21 (ChanClk), JP9.1, PM1.7 (BIO1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, CON1.2, GPIO1.6 (GND), GPIO1.9 (GND), GPIO1.14 (GND), GPIO1.20 (GND), GPIO1.25 (GND), GPIO1.30 (GND), GPIO1.34 (GND), GPIO1.39 (GND), GR1.4 (GND), GR2.4 (GND), GR3.4 (GND), J1.38 (GND), JP8.1, PM1.5 (AGND), PM1.11 (BGND), PM2.5 (AGND), PM2.11 (BGND), PM3.5 (AGND), PM3.11 (BGND), SW1.2, TP1.1, TP1.2, U1.1 (GND), U2.1 (A0), U2.2 (A1), U2.3 (A2), U2.4 (GND)
ID_SC: GPIO1.28 (BCM1_ID_SC), JP9.2, RN1.4 (2), U2.6 (SCL)
ID_SD: GPIO1.27 (BCM0_ID_SD), JP10.2, RN1.3 (2), U2.5 (SDA)
unnamed: CON1.1, JP6.1
unnamed: GR1.3 (VCC), J3.1, JP1.2, PM1.6 (APWR), PM1.12 (BPWR)
unnamed: GR2.3 (VCC), J4.1, JP2.2, PM2.6 (APWR), PM2.12 (BPWR)
unnamed: GR3.3 (VCC), J5.1, JP3.2, PM3.6 (APWR), PM3.12 (BPWR)
unnamed: J1.40 (~RESET), SW1.1
unnamed: JP8.2, R1.2, U2.7 (WP)

Notes on the sheet:
RESET
GPIO-5V
XuLA-PWR
5V-PWR
GPIO-3.3V
GND
PM1-PWR
PM2-PWR
PM3-PWR
ID_SD
ID_SC
GPIO

Board: 2 copper layers, 65.0 x 56.0 mm, 33 parts (3 on the bottom side), 47 nets.

## Commit log

2015-04-02 Initial commit of combo StickIt! Motherboard / RPi B+ Hat.
2015-04-02 Updated PCB page title and comments.
2015-04-02 Updated component reference identifiers.
2015-05-06 Added Grove connectors.
2015-05-07 Changed PCB footprints for reset switch, capacitors and resistor.
2015-05-12 Removed two Grove connectors and rotated the others.
2015-05-12 Changed name to StickIt-Hat. Also restored and locked some silkscreen-only components that were removed by reimporting the netlist.
2015-06-02 Added manual for V4.0 StickIt! board.
2015-06-02 Modified PMOD LED digits test to use the master VHDL library.
2015-06-02 Added test for GPIO connections.
2015-06-04 Changed release date of V4.0 manual.
2015-06-04 dded README file for Github repo.
2015-06-04 Added images of StickIt! Board to README.
2015-07-17 Added manufacturers part numbers to some of the parts.
2016-02-01 Corrected manual for PM2 connector pin assignment.

Notices in the files:
pcb/StickIt-RPi.kicad_pcb:
(c) 2015
